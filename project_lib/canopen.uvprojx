# Keil uVision project canopen.uvprojx, settings and files
target CanOpenStack (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: canopen +hex (library)
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\canopen;..\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CANOPEN
    ../canopen/: cm4.c dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c canopen.c
    ../canopen/object/: MagNet.c
target App (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: as above
  output: canopen +hex (library)
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\canopen;..\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
